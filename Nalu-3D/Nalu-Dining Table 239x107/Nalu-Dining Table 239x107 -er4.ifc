Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Nalu-Dining Table 239x107 -er4.ifc
Time: 2024-10-24T08:51:33
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (104)
Name
 | Nalu-Dining Table 239x107_0 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_1 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_2 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_3 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_4 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_5 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_6 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_7 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_8 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_9 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_10 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_11 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_12 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_13 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_14 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_15 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_16 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_17 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_18 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_19 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_20 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_21 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_22 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_23 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_24 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_25 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_26 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_27 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_28 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_29 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_30 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_31 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_32 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_33 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_34 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_35 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_36 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_37 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_38 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_39 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_40 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_41 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_42 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_43 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_44 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_45 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_46 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_47 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_48 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_49 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_50 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_51 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_52 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_53 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_54 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_55 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_56 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_57 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_58 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_59 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_60 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_61 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_62 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_63 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_64 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_65 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_66 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_67 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_68 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_69 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_70 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_71 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_72 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_73 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_74 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_75 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_76 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_77 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_78 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_79 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_80 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_81 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_82 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_83 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_84 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_85 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_86 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_87 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_88 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_89 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_90 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_91 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_92 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_93 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_94 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_95 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_96 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_97 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_98 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_99 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_100 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_101 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_102 - ObjectType: SketchupGroup
 | Nalu-Dining Table 239x107_103 - ObjectType: SketchupGroup
